# IAR project at32uc3a-isp.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x0400
  General.GCStackSize: 0x0400
  General.GHeapSize: 0x0400
  ICCAVR32.CCDefines: BOARD=EVK1100; ISP_OSC=0
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\..\..\DRIVERS\WDT\; ..\..\..\..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\ENUM\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\ENUM\DEVICE\; ..\..\..\..\..\..\..\..\SERVICES\USB\; ..\..\; ..\..\BOOT\; ..\..\INTC\; ..\..\ENUM\; ..\..\ENUM\DEVICE\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.AIncludePaths: ..\..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  postbuild: cmd /c cd $PROJ_DIR$ && sh post-build.sh
  XLINK.XclFile: lnkat32uc3a-isp.xcl
  group (top)
    ../../BOOT/: boot.s82
    ../../INTC/: intc.c
    ../../: isp.c usb_dfu.c
    ../../ENUM/DEVICE/: usb_descriptors.c usb_specific_request.c
  group Drivers
    ../../../../../../../../DRIVERS/FLASHC/: flashc.c
    ../../../../../../../../DRIVERS/PM/: pm.c
    ../../../../../../../../DRIVERS/WDT/: wdt.c
  group Drivers/USBB
    ../../../../../../../../DRIVERS/USBB/: usb_drv.c
  group Drivers/USBB/Enum
    ../../../../../../../../DRIVERS/USBB/ENUM/: usb_task.c
  group Drivers/USBB/Enum/Device
    ../../../../../../../../DRIVERS/USBB/ENUM/DEVICE/: usb_device_task.c usb_standard_request.c
