# IAR project dip204_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allan.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\DRIVERS\CPU\CYCLE_COUNTER\; ..\..\..\..\..\..\COMPONENTS\DISPLAY\DIP204; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\..\DRIVERS\PWM\; ..\..\..\..\..\..\DRIVERS\SPI\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../../: dip204.c
    ../../: dip204_example.c
  group Support
    ../../../../../../DRIVERS/INTC/: exception.s82 intc.c
    ../../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../../DRIVERS/PM/: pm.c
    ../../../../../../DRIVERS/PWM/: pwm.c
    ../../../../../../DRIVERS/SPI/: spi.c
    ../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
