<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\at45dbx_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


