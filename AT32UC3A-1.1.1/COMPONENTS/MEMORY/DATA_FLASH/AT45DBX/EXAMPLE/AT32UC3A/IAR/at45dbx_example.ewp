# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCIncludePath2: ..\..\..\; ..\..\; ..\..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\..\..\DRIVERS\SPI\; ..\..\..\..\..\..\..\SERVICES\MEMORY\CTRL_ACCESS
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.AIncludePaths: ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../../: at45dbx.c
    ../../: at45dbx_example.c
  group Support
    ../../../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../../../DRIVERS/PM/: pm.c
    ../../../../../../../UTILS/DEBUG/: print_funcs.c
    ../../../../../../../DRIVERS/SPI/: spi.c
    ../../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
    ../../../../../../../DRIVERS/USART/: usart.c
