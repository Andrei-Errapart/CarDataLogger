# IAR project sdramc_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCIncludePath2: ..\..\..\..\; ..\..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\..\..\DRIVERS\EBI\SDRAMC\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.AIncludePaths: ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../../../../../../BOARDS/EVK1100/: led.c
    ../../../../../../../DRIVERS/EBI/SDRAMC/: sdramc.c
    ../../: sdramc_example.c
  group Support
    ../../../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../../../DRIVERS/PM/: pm.c
    ../../../../../../../UTILS/DEBUG/: print_funcs.c
    ../../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
    ../../../../../../../DRIVERS/USART/: usart.c
