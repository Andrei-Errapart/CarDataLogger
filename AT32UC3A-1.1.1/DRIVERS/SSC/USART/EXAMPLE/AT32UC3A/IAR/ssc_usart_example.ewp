# IAR project ssc_usart_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allan.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\..\DRIVERS\SSC\USART\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../../: ssc_usart.c
    ../../: ssc_usart_example.c
  group Support
    ../../../../../INTC/: exception.s82 intc.c
    ../../../../../GPIO/: gpio.c
    ../../../../../PM/: pm.c
    ../../../../../../UTILS/DEBUG/: print_funcs.c
    ../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
    ../../../../../USART/: usart.c
