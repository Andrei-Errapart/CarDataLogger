# IAR project eic_example2.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x800
  General.GCStackSize: 0x800
  General.GHeapSize: 0x8000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCIncludePath2: ..\..\..\..\EIC\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\INTC\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AAVR32.AIncludePaths: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\DRIVERS\INTC\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../../: eic.c
    ../../: eic_example2.c
  group Support
    ../../: exception.s82
    ../../../../GPIO/: gpio.c
    ../../../../INTC/: intc.c
    ../../../../PM/: pm.c
    ../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
